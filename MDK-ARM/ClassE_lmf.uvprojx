# Keil uVision project ClassE_lmf.uvprojx, settings and files
target ClassE_lmf (6160000::V6.16::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ClassE_lmf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../dwt_delay;../lwevt;../lwrb;../multibutton;../multitimer;..\midware\inc;..\pid;..\lwrb\include\lwrb
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lwrb
    ../lwrb/lwrb/: lwrb.c lwrb_ex.c
  group dwt_delay
    ../dwt_delay/: dwt_delay.c
  group multibutton
    ../multibutton/: multi_button.c
  group multimer
    ../multitimer/: MultiTimer.c
  group Midware
    ../midware/src/: app_event.c bsp_fan_pid.c bsp_multibutton.c bsp_ringbuffer.c bsp_soft_timer.c app_callbacks.c bsp_led.c bsp_relay.c bsp_sys_ctrl.c rf_matching.c command_parser.c bsp_get_temp.c ADC_sin_test.c
  group pid
    ../pid/: PID.c
software components: CMSIS:CORE 6.2.0
